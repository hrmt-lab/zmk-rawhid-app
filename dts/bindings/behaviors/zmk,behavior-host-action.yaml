## dts/bindings/behaviors/zmk,behavior-host-action.yaml
```yaml
description: RawHID host action behavior

compatible: "zmk,behavior-host-action"

include: two_param.yaml
```
